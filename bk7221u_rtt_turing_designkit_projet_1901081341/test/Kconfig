## bk7221u_rtt_turing_designkit_projet_1901081341/test/Kconfig
```kconfig
menu "Test samples"
    config RT_USING_IPERF_TEST
        bool "Enable Iperf Test"
        default n

endmenu
```
